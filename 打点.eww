<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\&#x6253;&#x70B9;.ewp</path>
  </project>
  <batchBuild/>
</workspace>


